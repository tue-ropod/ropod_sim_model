Commit message: Simulator with noise added

File: urdf/ropod.urdf (robot description, URDF)
Before this commit: robot visual, 1 links, 0 joints
Links:
- link base_link: geometry collision box ; collision sphere 
